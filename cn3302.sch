File: cn3302.sch (EAGLE design)
At the start: 20 parts, among them M1 CN3302SOP-8

Commit message: pcb
Other:
- moved on the sheet: C1, C2, C3, C4, C5, C6, C7, C8, D1, D2, L1, LED1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
