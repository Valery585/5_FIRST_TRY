File: cn3302  pcbWAY.brd (EAGLE design)
At the start: 56 x 20 mm, 20 parts, among them M1 CN3302SOP-8, T1 AOD9N50

Commit message: добавил word
Routing:
- net GND: track 156.3 -> 155.7 mm
